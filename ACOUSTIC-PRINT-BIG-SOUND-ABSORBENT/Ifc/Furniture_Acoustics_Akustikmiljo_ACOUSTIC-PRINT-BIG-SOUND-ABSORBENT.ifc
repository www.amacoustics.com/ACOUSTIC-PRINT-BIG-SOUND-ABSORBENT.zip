Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Furniture_Acoustics_Akustikmiljo_ACOUSTIC-PRINT-BIG-SOUND-ABSORBENT.ifc
Time: 2020-05-11T10:38:41
Author: Supplier
Organization: BIMobject
Written by: IFC Engine DLL 2017-09-06
Made in: BIMobject-Lena
Authorization: Full Scope

# IfcBuildingStorey
Elevation: 0 m

# IfcFurnishingElement: ACOUSTIC PRINT BIG SOUND ABSORBENT
ePset_BIMobjectScript - LOD: 300; Custom width: 0.025; Custom height: 0.002
ePset_BIMobject_BO - ProductName (BO_prodinfo): ACOUSTIC PRINT BIG SOUND ABSORBENT; SKU (BO_prodsku): ACOUSTIC-PRINT-BIG-SOUND-ABSORBENT; ManufacturName (BO_Manufac): Akustikmiljö; EditionNumber (BO_edinum): 1; Width (BO_width): 0; Height (BO_height): 0; Depth (BO_depth): 0; Weight (BO_weight): 0; QR (BO_boqrurl): http://bimobject.com/akustikmiljo/product/ACOUSTIC-PRINT-BIG-SOUND-ABSORBENT; ProductDataUrl (BO_prodaturl): bimobject.com/akustikmiljo/product/ACOUSTIC-PRINT-BIG-SOUND-ABSORBENT; ProductUrl (BO_producturl): https://www.amacoustics.com/products/acoustic-print-big-sound-absorbent; BimObjectMainCategory (BO_bomaincat): Furniture; BimObjectMainCategoryCode (BO_bomaincat_code): furniture; BimObjectCategory (BO_bocat): Acoustics; BimObjectCategoryCode (BO_bocat_code): furniture-acoustics; IfcClassification (BO_ifcclas): Furniture; RegionEurope (BO_europe): All; RegionNorthAmerica (BO_northamerica): All; RegionSouthAmerica (BO_southamerica): All; RegionMiddleEast (BO_middleeast): All; RegionAsia (BO_asia): All; RegionOceania (BO_oceania): All; RegionAfrica (BO_africa): All; RegionAntarctica (BO_antarctica): All
